# Autodesk Inventor assembly: Staircase
## iProperties
Created: 2006-03
Part Number: Staircase
Document SubType Name: Assembly
Designer: Carlo
Author: Carlo
